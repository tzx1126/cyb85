## config/boards/shields/cyb/Kconfig.shield
```kconfig
# Copyright (c) 2020 The ZMK Contributors
# SPDX-License-Identifier: MIT

config SHIELD_cyb
	def_bool $(shields_list_contains,cyb)
```
